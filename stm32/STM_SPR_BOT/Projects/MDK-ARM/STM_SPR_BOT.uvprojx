# Keil uVision project STM_SPR_BOT.uvprojx, settings and files
target STM_SPR_BOT (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H750VBTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00020000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: STM_SPR_BOT +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32H750xx,USE_HAL_DRIVER
  c include: ..\..\Drivers\CMSIS\Device\ST\STM32H7xx\Include;..\..\Drivers\STM32H7xx_HAL_Driver\Inc;..\..\Drivers\CMSIS\Include;..\..\Drivers;..\..\User
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: ..\..\User\SCRIPT\qspi_code.scf.scf
  group Startup
    ../../Drivers/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h750xx.s
  group User
    ../../User/: main.c stm32h7xx_it.c stm32h7xx_hal_conf.h
    ../../Drivers/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/delay/: delay.c
    ../../Drivers/SYSTEM/sys/: sys.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_gpio.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_usart_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_sram.c stm32h7xx_ll_fmc.c stm32h7xx_hal_mdma.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_dac.c stm32h7xx_hal_dac_ex.c
  group BSP
    ../../Drivers/BSP/USART/: USART.C
    ../../Drivers/BSP/LCD/: lcd.c
    ../../Drivers/BSP/MPU/: MPU.C
    ../../Drivers/BSP/ADC/: ADC.C
    ../../Drivers/BSP/BTIM/: BTIM.C
    ../../Drivers/BSP/COMMAND/: Command.C
    ../../Drivers/BSP/SYN6288/: SYN6288.C
    ../../Drivers/BSP/ATIM/: ATIM.C
    ../../Drivers/BSP/DAC/: DAC.C
    ../../Drivers/BSP/KEY/: KEY.C
    ../../Drivers/BSP/ESP01S/: ESP01S.C
  group MIddlewares
    ../../Middlewares/MH_MALLOC/: MH_MALLOC.C
